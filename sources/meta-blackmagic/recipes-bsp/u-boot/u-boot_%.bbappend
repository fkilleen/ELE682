FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Empty-EEPROM-Fix-also-point-to-emmc1.patch"

